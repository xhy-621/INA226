# Keil uVision project project.uvprojx, settings and files
target project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS;.\Libraries\FWlib\inc;.\Libraries\Startup;.\Hardware\DELAY;.\Hardware\INA219;.\Hardware\IIC;.\Hardware\INA226
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ./Libraries/Startup/: startup_stm32f10x_hd.s
  group FWLIB
    ./Libraries/FWlib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_iwdg.c
  group HARDWARE
    ./Hardware/DELAY/: delay.c
    ./Hardware/INA219/: ina219.c
    ./Hardware/INA226/: ina226.c
  group USER
    ./User/: mian.c
